## config/boards/shields/touchpad_test/Kconfig.defconfig
```kconfig
if SHIELD_TOUCHPAD_TEST

config ZMK_KEYBOARD_NAME
    default "Touchpad Test"

endif
```
